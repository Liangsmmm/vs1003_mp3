# Keil uVision project stm32_ucosii.uvprojx, settings and files
target stm32_ucosii (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_ucosii
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\app;..\devices\inc;..\StdPeriphLibraries\CoreSupport;..\StdPeriphLibraries\DeviceSupport;..\StdPeriphLibraries\STM32F10x_StdPeriph_Driver\inc;..\ucosii\config;..\ucosii\core;..\ucosii\port;..\fatfs\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: main.c briupFontDraw.c musicPlayer.c musicUI.c musicControl.c
  group devices
    ../devices/src/: briupBasePeriph.c briupDelay.c briupFSMC.c briupKeyboard.c briupLCD.c briupMPU6050.c briupMPUDriver.c briupNVIC.c briupTIM2.c briupUsart.c inv_mpu.c briupRTC.c briupIWDG.c briupTouch.c briupSDIO.c briupSPI.c briupVS1003.c briupEXSRAM.c
  group fatfs
    ../fatfs/src/: diskio.c ff.c malloc.c
    ../fatfs/src/option/: cc936.c
  group boot
    ../StdPeriphLibraries/DeviceSupport/: startup_stm32f10x_hd.s
  group libraries
    ../StdPeriphLibraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c
    ../StdPeriphLibraries/CoreSupport/: core_cm3.c
    ../StdPeriphLibraries/DeviceSupport/: system_stm32f10x.c
  group ucosii_config
    ../ucosii/config/: includes.h os_cfg.h
  group ucosii_core
    ../ucosii/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucosii_port
    ../ucosii/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
